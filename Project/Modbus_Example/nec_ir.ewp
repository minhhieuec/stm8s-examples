# IAR project nec_ir.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; ..\..\Libraries\STM8S_StdPeriph_Driver\inc; freemodbus; freemodbus\modbus; port; freemodbus\modbus\include; freemodbus\modbus\functions; freemodbus\modbus\rtu
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: nec_ir.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c mbregs.c stm8s_conf.h stm8s_it.c
  group Driver
    ../../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c
  group freemodbus
    freemodbus/modbus/: mb.c
  group freemodbus/functions
    freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group freemodbus/include
    freemodbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group freemodbus/rtu
    freemodbus/modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group port
    port/: port.h portevent.c portserial.c porttimer.c
